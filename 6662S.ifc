Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-06T23:19:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 06 23:19:56 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{9F165B70-E4A1-4371-A310-E4D7EE1FB92F}\ifc * Database version: 5507 * Database creation date: Mon Aug 06 23:19:55 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 06 23:19:55 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 06 23:19:55 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6662S Shower panel, 6V, 6662S:6662S Shower panel, 6V:330007
In: Level 1
Type - PredefinedType: FAUCET; Material: Aluminum - Polished, Fine Textured - Black
Type - Dimensions(Type) - NominalDepth: 196.5 mm; NominalHeight: 1236 mm; NominalWidth: 335.092 mm
Type - Electrical(Type) - Battery: Lithium 2CR5 6 V; Operating Voltage: 6 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6662S; ConvergoRefNr: 0087-1809-0084-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 27/07/2018
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; EAN Number: 6414150047831; EMC Directive: 89/336/EEC; EN Standard: EN 15091; Noise Class: I (ISO 3822); NRF Number: 4200498; RSK Number: 8126156; STF Certificate: STF VTT-RTH-00114-11
Type - Identity Data(Type) - Class: Battery-operated, touchless; Group: Shower faucets; Manufacturer: Oras; Market: NOR;SWE; Model: 6662S Shower panel, 6V; Name_en: 6662S Shower panel, 6V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6662S; Product Datasheet: https://www.oras.com/datasheet/6662S/en; Product Family: Oras Electra; Product URL: https://www.oras.com/en/products/oras/product/6662S; Type Name: 6662S Shower panel, 6V
Type - Materials and Finishes(Type) - FaucetMainMaterial: Aluminum - Polished
Type - Mechanical(Type) - Advanced Features: Adjustable settings (with magnetic key); Afterflow Period: 5; Connection Size: G3/4; Flow Rate At 300kPa: 0.00635664 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/110373_PDM_945981_A_(945981-04-15).pdf; Installation Type: Wall-mounted; Installation Width: CC 150; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 300; Opening Range: 0-5 cm; Recognition Range: 60 cm (50 / 60 cm); Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP6662S/
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Aluminum/Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6662S; Features: Battery-operated, touchless; Finish: Polished; Grade: n/a; Material: Aluminium; ModelNumber: n/a; ModelReference: 6662S; Name: 6662S Shower panel, 6V; ReplacementCost: n/a; Shape: Sculptured; Size: 335x200x1236 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6662S; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6662S Shower panel, 6V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.724135 m2; InletConnectionSize: 10 mm; Volume: 0.0813718 m3
Identity Data - Mark: 10
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6662S: 6662S Shower panel, 6V; Family and Type: 6662S: 6662S Shower panel, 6V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6662S: 6662S Shower panel, 6V; Type Id: 6662S: 6662S Shower panel, 6V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
